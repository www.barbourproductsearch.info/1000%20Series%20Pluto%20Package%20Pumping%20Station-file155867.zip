Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-11-12T09:46:06
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_314370 | SINK
Port_314370 | SOURCE

# IfcFlowMovingDevice: NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_DeltaBespoke1000SeriesPlutoPackagedPumpStationGroundwater:DeltaDualPluto150230V1PhDMS-T001, NBS_DeltaMembraneSystemsLtd_PckgdPmpngStion_DeltaBespoke1000SeriesPlutoPackagedPumpStationGroundwater:DeltaDualPluto150230V1PhDMS-T001:314370
In: Level 0
Type - Classification: Pr_70_55_76_62 (Uniclass2015); Material: NBS_DeltaMembraneSystemsLtd_HDPE_Black (3), NBS_DeltaMembraneSystemsLtd_HDPE_Blue
Type - IFC - IfcExportAs: IfcPumpType; IfcExportType: SUBMERSIBLEPUMP
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_70_55_76_62:Packaged pumping stations; Color: n/a; Finish: n/a; Material: Polyethylene,Acrylonitrile butadiene styrene (ABS),Brass,Stainless steel,Cast iron,Plastic,Polypropylene; Shape: Other; Size: n/a; WarrantyDescription: One year; CodePerformance: n/a; Constituents: n/a; Description: Works in harmony with cavity drained systems to collect ground water via a perimeter drainage channel or modular drainage.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Delta Bespoke 1000 Series - Pluto Packaged Pump Station (Groundwater); Name: PackagedPumpingStations_DeltaBespoke1000Series-PlutoPackagedPumpStationGroundwater_DeltaDualPluto150230V1PhDMS-T001_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PackagedPumpingStations_DeltaBespoke1000Series-PlutoPackagedPumpStationGroundwater_DeltaDualPluto150230V1PhDMS-T001; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/f5be732f-4121-4595-ba14-d36fc172fc06/c7be16a3-0f90-4a8d-8b5c-b411c92bb11f; Uniclass2015Code: Pr_70_55_76_62; Uniclass2015Title: Packaged pumping stations; Uniclass2015Version: Products v1.35; Version: 3
Type - NBS_Data - Standards: To BS 8102:2022; ThirdPartyCertification: BBA Agrément Certificate; CollectionTankMaterial: High Density Polyethylene (HDPE); PumpsConfiguration: Twin pumps; PumpsPumpCharacteristic: Delta Dual Pluto 150 230 V/ 1 Ph; IntegralAccessories: Delta Pluto Extension Turret including clamping kit and seal; ContainsRedListMaterials: No; CountryOfProductManufacture: United Kingdom; Material: Polyethylene,Acrylonitrile butadiene styrene (ABS),Brass,Stainless steel,Cast iron,Plastic,Polypropylene; Recyclability: Yes; RecycledContent: 0; FlowRate: 4.1 L/s; CollectionTankType: Vertical; CollectionTankConfiguration: Wet well; CollectionTankCapacityMinimum: 156 L; Non-returnValve: Required; ConnectionsInletDiameter: DN 110; ConnectionsOutletDiameter: DN/OD 63; ConnectionsVentPipesMaterial: ABS; ConnectionsVentPipesDiameter: DN 50; Control: Control panel
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
